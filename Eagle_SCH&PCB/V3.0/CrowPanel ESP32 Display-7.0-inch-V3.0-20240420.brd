# Repository G-districts/CrowPanel-7.0-HMI-ESP32-Display-800x480

File readme.md:

### 1, Product picture

### 2, Product version number

|      | Hardware | Software | Remark |
| ---- | -------- | -------- | ------ |
| 1    | V1.0     | V1.0     | old |
| 1    | V2.0     | V2.0     | old |
| 1    | V3.0     | V3.0     | latest |

**Version 2.0** adds an automatic download feature over Version 1.0, eliminating the need to press boot+reset again before downloading the program.

**Version 3.0** adds touch timing control based on Version 2.0 to prevent touch failures. When writing programs, you need to build upon the Version 2.0 program to implement the timing control logic.

  PCA9557 Out;
  
  Out.reset();
  
  Out.setMode(IO_OUTPUT);  
  
  Out.setState(IO0, IO_LOW);
  
  Out.setState(IO1, IO_LOW);
  
  delay(20);
  
  Out.setState(IO0, IO_HIGH);
  
  delay(100);
  
  Out.setMode(IO1, IO_INPUT);

### 3, product information

- Model: 7.0 inch -CrowPanel ESP32 display
- Main Processor: ESP32-S3-WROOM-1-N4R8
- Resolution: 800*480
- Flash: 4MB
- PSRAM:8MB
- Touch Type: Capacitive Touch Screen
- Display Type: TN Panel
- Screen: TFT-LCD Screen
- Display driver: EK9716BD3 & EK73002ACGB
- External power supply: DC5V-2A
- Interface: 2\*UART0,2\*GPIO,2\*I2C,1\*Battery
- Button: BOOT Button and Reset Button
- Active Area: 153.84\*85.63mm(W*H)
- Working Temperature: -20℃～70℃
- Storage Temperature: -30℃～80℃

### 4, Use the driver module

| Name | dependency library |
| ---- | ------------------ |
| LVGL | lvgl/lvgl@8.3.3    |

### 5,Quick Start

##### Arduino IDE starts

1.Download the library files used by this product to the 'libraries' folder.

C:\Users\Documents\Arduino\libraries\

2.Open the Arduino IDE

3.Open the code configuration environment and burn it

##### ESP-IDF starts

1.Right-click on an empty space in the project folder and select "Open with VS Code" to open the project.

2.In the IDF plug-in, select the port, then compile and flash

##### PlatformIO starts

1.Right-click on an empty space in the project folder and select "Open with VS Code" to open the project.

2.In the PlatformIO plug-in, select the port, then compile and flash

##### Micropython starts

1,Right-click on an empty space in the project folder and select "Thonny" to open the project.

2,In thonny software, select the master and port, then run the program

### 6,Folder structure.

|--3D file： Contains 3D model files (.stp) for the hardware. These files can be used for visualization, enclosure design, or integration into CAD software.

|--Datasheet: Includes datasheets for components used in the project, providing detailed specifications, electrical characteristics, and pin configurations.

|--Eagle_SCH&PCB: Contains **Eagle CAD** schematic (`.sch`) and PCB layout (`.brd`) files. These are used for circuit design and PCB manufacturing.

|--example: Provides example code and projects to demonstrate how to use the hardware and libraries. These examples help users get started quickly.

|--factory_firmware: Stores pre-compiled factory firmware that can be directly flashed onto the device. This ensures the device runs the default functionality.

|--factory_sourcecode: Contains the source code for the factory firmware, allowing users to modify and rebuild the firmware as needed.

### 7,Pin definition

class LGFX : public lgfx::LGFX_Device
{
public:

  lgfx::Bus_RGB     _bus_instance;
  lgfx::Panel_RGB   _panel_instance;

  LGFX(void)
  {

    {
      auto cfg = _bus_instance.config();
      cfg.panel = &_panel_instance;
    
      cfg.pin_d0  = GPIO_NUM_15; // B0
      cfg.pin_d1  = GPIO_NUM_7;  // B1
      cfg.pin_d2  = GPIO_NUM_6;  // B2
      cfg.pin_d3  = GPIO_NUM_5;  // B3
      cfg.pin_d4  = GPIO_NUM_4;  // B4
    
      cfg.pin_d5  = GPIO_NUM_9;  // G0
      cfg.pin_d6  = GPIO_NUM_46; // G1
      cfg.pin_d7  = GPIO_NUM_3;  // G2
      cfg.pin_d8  = GPIO_NUM_8;  // G3
      cfg.pin_d9  = GPIO_NUM_16; // G4
      cfg.pin_d10 = GPIO_NUM_1;  // G5
    
      cfg.pin_d11 = GPIO_NUM_14; // R0
      cfg.pin_d12 = GPIO_NUM_21; // R1
      cfg.pin_d13 = GPIO_NUM_47; // R2
      cfg.pin_d14 = GPIO_NUM_48; // R3
      cfg.pin_d15 = GPIO_NUM_45; // R4
    
      cfg.pin_henable = GPIO_NUM_41;
      cfg.pin_vsync   = GPIO_NUM_40;
      cfg.pin_hsync   = GPIO_NUM_39;
      cfg.pin_pclk    = GPIO_NUM_0;
      cfg.freq_write  = 15000000;
    
      cfg.hsync_polarity    = 0;
      cfg.hsync_front_porch = 40;
      cfg.hsync_pulse_width = 48;
      cfg.hsync_back_porch  = 40;
    
      cfg.vsync_polarity    = 0;
      cfg.vsync_front_porch = 1;
      cfg.vsync_pulse_width = 31;
      cfg.vsync_back_porch  = 13;
    
      cfg.pclk_active_neg   = 1;
      cfg.de_idle_high      = 0;
      cfg.pclk_idle_high    = 0;
    
      _bus_instance.config(cfg);
    }
            {
      auto cfg = _panel_instance.config();
      cfg.memory_width  = 800;
      cfg.memory_height = 480;
      cfg.panel_width  = 800;
      cfg.panel_height = 480;
      cfg.offset_x = 0;
      cfg.offset_y = 0;
      _panel_instance.config(cfg);
    }
    _panel_instance.setBus(&_bus_instance);
    setPanel(&_panel_instance);

  }
};

 #define TOUCH_GT911_SCL 20//20
 #define TOUCH_GT911_SDA 19//19

## EAGLE design Eagle_SCH&PCB/V3.0/CrowPanel ESP32 Display-7.0-inch-V3.0-20240420.brd

Parts:
C1: 0.1uF/NC; DISCRETE_C0603
C2, C4, C13, C20, C22, C24, C33, C50: 100nF; C0603
C3, C6, C8, C15, C18, C36, C44: 1uF; 0603
C5: 1uF; C0603
C7, C10, C19, C23, C37, C42, C43, C46: 22uF; 0805
C9, C17, C21, C26, C34, C35, C45, C76: 100nF; 0603
C11: 4.7uF; 0603
C12, C29, C30: 1uF; DISCRETE_C0603
C14, C16: 1nF; C0603
C25, C32: 47uF; 0805
C27, C28: 100NF; 0603
C31: 10uF; DISCRETE_C0603
C38, C39: 10uF; C0603
C40, C41: 1uF; 0805
C47, C48, C49: 10uF; 0805_S
C51: 4.7uF/NC; 0603
C52: 100NF; A_XBJ_0603
C54: 4.7uF; DISCRETE_C0603
D1, D6: SS24B/SMB; 214AB
D2: BZT52C-18V; DISCRETE_SOD123
D3: SS24/SMB; 214AB
D4: BZT52C-8.2V; DISCRETE_SOD123
D5: IN5817; DO-214AC
IC1: PCA9557-16P; TSSOP16
J1, J5: PH2.0WT-2PIN
J2: 7.0-DIANRONG-50PIN-0.5MM; 7.0-DAINRONG-50PIN-0.5MM
J3: USB_TYPE-C_16PIN3.0USB; KEVIN_3.0TYPEC-SMD
J4: 2.54-8PIN-WOTIE; 2.54-8P-WOTIE
J6, J7, J10: CONNECTOR_TWIG-4P-2.0-SMD-FEMALE-REINFORCE90D; CONNECTOR_4P-SMD-2.0-90D
K1, K4: BUTTON; 157SW
L1, L2, L4: L-0530; CD54_CD54
L5: CD32_6.8uH; CD32
LED1: RED; DISCRETE_LED-0603
P2, P4: FPC-6PIN-0.5MM
Q1, Q2: BAT54S; SOT23-3
Q3, Q4, Q30: PMOS-3401-4A; SOT-23
Q5, Q6: S8050; SPARKFUN_SOT23
Q9, Q10: S9013; SOT23@1
R1: 75K; DISCRETE_R0603
R2: 10.5K; DISCRETE_R0603
R3, R41, R42, R61: 4.7K; DISCRETE_R0603
R4, R10, R12, R19, R25, R46, R49, R51, R53: 0R; DISCRETE_R0603
R5, R32, R35, R37, R39, R57: 10K/NC; DISCRETE_R0603
R6: 15K; DISCRETE_R0603
R7, R13, R14: 5.1K; DISCRETE_R0603
R8, R9: 22R; DISCRETE_R0603
R11: 100R; R0603
R15: 2K; DISCRETE_R0603
R16, R17, R18, R21, R23, R24, R33, R34, R36, R43, R44, R67, R90: 10K; DISCRETE_R0603
R20: 45.3K; DISCRETE_R0603
R22: 100K; DISCRETE_R0603
R26, R38: 0R; R0603
R27, R28: 47K; DISCRETE_R0603
R29: 1.8R 1%; DISCRETE_R0603
R30: 53.6K; DISCRETE_R0603
R31: 10K/NC; R0603
R40: 0R/NC; R0603
R45, R74, R75: 1K; DISCRETE_R0603
R47: NC/1K; DISCRETE_R0603
R48, R54, R172: 100K; R0603
R50, R52, R56, R59, R60: 0R/NC; DISCRETE_R0603
R55: 100k; R0603
R58: 10k; R0603
R71, R72: 470R; DISCRETE_R0603
R91: 7.5K; DISCRETE_R0603
SD1: HOLDER-MICROSD-9P; 9P-SMD-W/-RING
U1, U3: RY3420; A_XBJ_SOT23-5
U2: ESP32-S; ESP32-S3
U4: MT9201; SOT23-6
U5: LP3318; LP3318_SOT23-5
U6: CH340C; SOP-16
U11: NS4168-ESOP-8
U26: 4054A; SOP23-5

Connections:
3V3: C2.1, C4.2, C7.2, C8.2, C9.2, C12.2, C13.1, C20.1, C26.1, C29.2, C30.2, C31.2, C32.2, C33.1, C52.1, C54.2, IC1.16 (VCC), J4.2, J4.6, J6.3, J7.3, J10.3, L4.2, P2.5 (2), P4.5 (2), Q4.2 (S), R3.2, R5.1, R10.1, R16.1, R17.1, R18.1, R20.1, R22.2, R23.1, R24.1, R41.2, R42.2, R47.2, R48.1, R56.1, R61.2, R67.1, SD1.4 (VDD), U2.2 (3V3), U6.4 (V3), U6.16 (VCC)
AVDD_10V: C10.2, C15.2, C17.2, D1.2 (-), J2.P$8 (AVDD), Q1.1, R1.1, R90.1
BAT+: C47.2, C48.2, D5.A, J1.P$1, Q3.3 (D), U26.3 (BAT)
D+: J3.A6 (DP1), J3.B6 (DP2), R9.1
D-: J3.A7 (DN1), J3.B7 (DN2), R8.1
DCLK1: C1.2, J2.P$14 (DCLK), R38.2
DTR: Q10.2 (E), R75.2, U6.13 (DTR#)
EN_RESET: C11.1, K4.2, Q9.3 (C), R18.2, R40.1, R46.2, R54.2, U2.3 (EN)
GND: C1.1, C2.2, C3.1, C4.1, C5.2, C6.1, C7.1, C8.1, C9.1, C10.1, C11.2, C12.1, C13.2, C14.2, C15.1, C16.2, C17.1, C18.1, C19.1, C20.2, C21.1, C22.1, C23.1, C24.2, C25.2, C26.2, C29.1, C30.1, C31.1, C32.1, C33.2, C34.1, C35.1, C36.1, C37.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.2, C51.2, C52.2, C54.1, C76.1, D2.+, D4.-, IC1.3 (A0), IC1.4 (A1), IC1.5 (A2), IC1.8 (VSS), J1.P$2, J1.P$3, J1.P$4, J2.P$3 (GND3), J2.P$13 (GND2), J2.P$15 (GND1), J2.P$16 (R0), J2.P$17 (R1), J2.P$18 (R2), J2.P$24 (G0), J2.P$25 (G1), J2.P$32 (B0), J2.P$33 (B1), J2.P$34 (B2), J2.P$46 (GND), J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.P$6, J3.P$7, J3.P$8, J3.P$9, J4.1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
I2S_BCLK: R19.1, U11.3 (BCLK)
I2S_CTRL: R22.1, U11.1 (CTRL)
I2S_SDIN: R4.1, U11.4 (SDATA)
INTE: IC1.7 (IO1), P2.3 (4), P4.3 (4), R57.2
IO0_BOOT_CLK: K1.2, Q10.3 (C), R38.1, U2.27 (IO0)
IO1_G7: J2.P$31 (G7), U2.39 (IO1)
IO2_LCD_BL_CTR: R11.2, U2.38 (IO2), U4.4 (4-EN)
IO3_G4: J2.P$28 (G4), U2.15 (IO3)
IO4_B7: J2.P$39 (B7), U2.4 (IO4)
IO5_B6: J2.P$38 (B6), U2.5 (IO5)
IO6_B5: J2.P$37 (B5), U2.6 (IO6)
IO7_B4: J2.P$36 (B4), U2.7 (IO7)
IO8_G5: J2.P$29 (G5), U2.12 (IO8)
IO9_G2: J2.P$26 (G2), U2.17 (IO9)
IO10_TF_CS: R67.2, SD1.2 (CS), U2.18 (IO10)
IO11_TF_SPI_MOSI/TP_DIN: R23.2, SD1.3 (DI), U2.19 (IO11)
IO12_TF_CLK/TP_CLK: SD1.5 (SCLK), U2.20 (IO12)
IO13_TF_SPI_MISO/TP_OUT: R24.2, SD1.7 (DO), U2.21 (IO13)
IO14_R3: J2.P$19 (R3), U2.22 (IO14)
IO15_B3: J2.P$35 (B3), U2.8 (IO15)
IO16_G6: J2.P$30 (G6), U2.9 (IO16)
IO17_I2S_SDIN: R4.2, U2.10 (IO17)
IO18_I2S_LRCLK: R12.2, U2.11 (IO18)
IO19_I2C_SDA: IC1.2 (SDA), J4.7, J6.2, P2.2 (5), P4.2 (5), R41.1, U2.13 (IO19)
IO20_I2C_SCL: IC1.1 (SCL), J4.8, J6.1, P2.1 (6), P4.1 (6), R42.1, U2.14 (IO20)
IO21_R4: J2.P$20 (R4), U2.23 (IO21)
IO38_D: J4.4, J7.1, R5.2, R57.1, U2.31 (IO38)
IO39_HSYNC: J2.P$40 (HSYNC), U2.32 (IO39)
IO40_VSYNC: J2.P$41 (VSYNC), U2.33 (IO40)
IO41_DE: J2.P$42 (DE), U2.34 (IO41)
IO42-I2S_BCLK: R19.2, U2.35 (IO42)
IO45_R7: J2.P$23 (R7), R31.2, U2.26 (IO45)
IO46_G3: J2.P$27 (G3), U2.16 (IO46)
IO47_R5: J2.P$21 (R5), U2.24 (IO47)
IO48_R6: J2.P$22 (R6), U2.25 (IO48)
L/R: J2.P$12 (L/R), R34.1, R35.2
LCD-POWER-C: IC1.10 (IO3), R60.2
LCD-RESET: IC1.9 (IO2), R59.2
LCD_LEDA: C19.2, C21.2, D6.2 (-), J2.P$49 (LED-A), J2.P$50 (LED_A), U4.5 (5-OV)
LCD_LEDK: J2.P$47 (LED-K), J2.P$48 (LED_K), R29.1, U4.3 (3-FB)
LRCLK: R12.1, U11.2 (LRCLK)
unnamed: LED1.+, R3.1
unnamed: J2.P$45 (VCOM), R25.2
unnamed: C14.1, C38.1, J5.P$2
unnamed: J2.P$5 (VCOM1), R26.2
unnamed: C38.2, U11.8 (VOP)
unnamed: R1.2, R2.1, U5.3 (FB)
unnamed: C39.2, U11.5 (VON)
unnamed: C27.2, C28.2, D1.1 (+), L1.2, U5.1 (LX)
unnamed: C27.1, Q1.3
unnamed: J3.A5 (CC1), R13.2
unnamed: J2.P$43 (MODE), R36.1, R37.2
unnamed: L4.1, U1.3 (SW)
unnamed: J2.P$4 (DITHB), R39.1
unnamed: C16.1, C39.1, J5.P$1
unnamed: D6.1 (+), L5.2, U4.1 (1-SW)
unnamed: J3.B5 (CC2), R14.1
unnamed: R30.2, R43.1, U3.5 (FB)
unnamed: L2.1, U3.3 (SW)
unnamed: R20.2, R21.1, U1.5 (FB)
unnamed: Q3.1 (G), R44.2, R45.1
unnamed: R15.1, U26.5 (PROG)
unnamed: Q5.1 (B), R11.1, R58.2
unnamed: C28.1, Q2.3
unnamed: R49.1, R51.2, U3.1 (EN)
unnamed: Q4.1 (G), Q6.3 (C), R48.2
unnamed: C35.2, Q1.2, R7.1
unnamed: C34.2, Q2.1, R6.1
unnamed: R52.2, R53.1, U5.4 (EN)
unnamed: Q9.1 (B), R75.1
unnamed: Q6.1 (B), R54.1, R55.2, R60.1
unnamed: Q5.3 (C), Q30.1 (G), R172.2
unnamed: Q10.1 (B), R74.1
unnamed: R72.2, U6.2 (TXD)
unnamed: R71.2, U6.3 (RXD)
unnamed: R16.2, SD1.1 (DATA2)
unnamed: R17.2, SD1.8 (DATA1)
unnamed: IC1.15 (RESET/), R61.1
RTS: Q9.2 (E), R74.2, U6.14 (RTS#)
TFT-3V3: C5.1, C22.2, J2.P$44 (DVDD), Q4.3 (D), R32.2, R34.2, R36.2, R39.2, R56.2
TFT_RESET: C51.1, J2.P$7 (RESET), R46.1, R47.1, R59.1
TP-RESET: IC1.6 (IO0), P2.6 (1), P4.6 (1), R40.2
U/D: J2.P$11 (U/D), R32.1, R33.2
UART0_RXD0: J10.1, R72.1, U2.36 (RXD0)
UART0_TXD0: J10.2, R71.1, U2.37 (TXD0)
USB_D+: R9.2, U6.5 (UD+)
USB_D-: R8.2, U6.6 (UD-)
VBUS: C49.2, C50.1, D3.1 (+), J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), R45.2, U26.4 (VCC)
VCOM: C37.2, C44.2, C45.2, C76.2, L2.2, R25.1, R26.1, R30.1, R90.2, R91.1
VDD: C24.1, C25.1, R10.2, R50.2, U11.6 (VDD)
VGH+18V: C40.2, D2.-, J2.P$10 (VGH), R7.2, R27.1
VGL-8.2V: C41.2, D4.+, J2.P$9 (VGL), R6.2, R28.1
VIN: C3.2, C6.2, C23.2, C36.2, C42.2, C46.2, D3.2 (-), D5.C, L1.1, Q3.2 (S), Q30.2 (S), R50.1, R51.1, R52.1, R172.1, U1.1 (EN), U1.4 (VIN), U3.4 (VIN), U5.5 (VIN)
VIN2: C18.2, C43.2, L5.1, Q30.3 (D), R49.2, R53.2, U4.6 (6-VIN)

Notes on the sheet:
Vout=0.6*(R20/R21 +1)=3.3V
系统3.3V电源
UART0接口
主控 ESP32-S3-WROOM-1-N4R8
USB type-c座子
电池及控制电路
IO0: 低电平：下载启动 高电平：SPI启动
EN: 高电平：芯片使能； 低电平：芯片关闭。
USB转串口
IIS 功放:NS4168
TF Card
BOOT
RESET
POWER LED
LCD+TP 接口
电容屏TP
Iout=0.2/R29
L/R和U/D，预留上下拉
数据传输模式选择，预留上下拉
R37/R36选DE和H/V
Vout=0.6*(R20/R21 +1)=10V
正负压源
LCD恒流驱动
默认使用右边P4的触摸接口，如需更换使用左边P2触摸接口,BOM需要更改使用P2
默认使用右边P4的触摸接口，如需更换使用左边P2触摸接口,PCB的排线孔也要更改
HM3416H更换为RY3420
VCOM=0.6*(R20/R21 +1)=3.8V
500mA
BAT
PCA9557 ADDRESS:
0X18
PCA9557PW,118

Board: 2 copper layers, 181.0 x 103.9 mm, 169 parts (1 on the bottom side), 103 nets.

Other parts of the board:
U$10: 7.0底框
U$15: 7.0板框
U$76: LOGE-2.0
U$78: LOGLE

## Commit log (part)

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2025-12-12 Update readme with complete code link
    Added a link to the complete code for the PlatformIO project.
2026-04-19 Replace Arduino image in README
    Updated image link in the README file.
2026-06-16 V3.0
2026-06-16 Move ESP_IDF examples to V1.0_and_V2.0
2026-06-22 Micropython
2026-06-22 ESP_IDF
2026-06-23 PlatformIO
2026-06-25 .pio
